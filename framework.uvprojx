# Keil uVision project framework.uvprojx, settings and files
target framework (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: framework (library)
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=6 wLevel=2
  c misc: --cpp11
  asm include: ..\framework
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group debug
    ./: main.cpp
  group include
    ./: framework.h
  group hal
    hal/: hal.h AnalogDigitalConverter.hpp AnalogDigitalConverterChannel.hpp Base.hpp GeneralPurposeIO.hpp GeneralPurposePin.hpp Pin.hpp Timer.hpp PinEdgeTrigger.hpp InterIntegratedCircuit.hpp SerialPeripheral.hpp SerialPeripheralSlot.hpp SerialPort.hpp
  group lang
    lang/: lang.h Integer.hpp Object.hpp
  group util
    util/: util.h Executor.hpp Scanner.hpp BlockPool.hpp Pool.hpp TimerScheduler.hpp
    ./util/: Timer.hpp TimerTask.hpp
  group io
    io/: io.h InputStream.hpp OutputStream.hpp
    ./io/: Stream.hpp Transfer.hpp
