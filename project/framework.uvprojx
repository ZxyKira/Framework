# Keil uVision project framework.uvprojx, settings and files
target framework (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: framework (library)
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group include
    ../: framework.h
    ./: test.cpp
  group hal
    ../hal/: AnalogDigitalConverter.hpp AnalogDigitalConverterChannel.hpp Base.hpp GeneralPurposeIO.hpp GeneralPurposePin.hpp hal.h Pin.hpp Timer.hpp PinEdgeTrigger.hpp InterIntegratedCircuit.hpp SerialPeripheral.hpp SerialPeripheralSlot.hpp SerialPort.hpp
  group lang
    ../lang/: Integer.hpp Object.hpp lang.h
  group util
    ../util/: Executor.hpp Scanner.hpp TimerScheduler.hpp util.h BlockPool.hpp
  group io
    ../io/: InputStream.hpp OutputStream.hpp io.h
